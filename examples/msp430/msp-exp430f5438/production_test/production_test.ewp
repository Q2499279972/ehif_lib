# IAR project production_test.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430xlfn.h
  General.OGChipSelectMenu: MSP430F5438 MSP430F5438
  General.GStackSize2: 160
  General.GHeapSize2: 160
  General.RadioHeapSizeType: 0
  ICC430.newCCIncludePaths: ..\common\; ..\..\..\..\source\; ..\..\..\..\source\hal\msp430\; ..\..\..\..\source\hal\msp430\msp-exp430f5438\; ..\..\..\..\source\little_endian\
  ICC430.CCOptLevel: 2
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F5438.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.RTConfigPath: xxx.h
  ICC430.CCDefines: NDEBUG
  ICC430.CCOptLevel: 3
  XLINK.XclFile: lnk0t.xcl
  group ehif_lib
    ../../../../source/: cc85xx_ehif_basic_op.c cc85xx_ehif_basic_op.h cc85xx_ehif_bootloader.c cc85xx_ehif_bootloader.h cc85xx_ehif_cmd_exec.c cc85xx_ehif_cmd_exec.h cc85xx_ehif_utils.h
  group ehif_lib/hal_msp_exp430f5438
    ../../../../source/hal/msp430/msp-exp430f5438/: cc85xx_ehif_hal_board.c cc85xx_ehif_hal_board.h
    ../../../../source/hal/msp430/: cc85xx_ehif_hal_mcu.h
  group ehif_lib/little_endian
    ../../../../source/little_endian/: cc85xx_ehif_defs.h cc85xx_ehif_field_op.c
  group example
    ./: headset_preloaded_demo_application_master.c headset_preloaded_demo_application_slave.c headset_preloaded_demo_prodtest_master.c headset_preloaded_demo_prodtest_slave.c main.c
  group example/hal_msp_exp430f5438
    ../common/: hal_board.c hal_buttons.c hal_int.c hal_lcd.c hal_mcu.c hal_tlv.c
